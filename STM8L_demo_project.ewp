# IAR project STM8L_demo_project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L052C6 STM8L052C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L05X_MD_VL
  ICCSTM8.CCIncludePath2: app; lib\inc; sys; user; function
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8L_demo_project.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group APP
    app/: getid.c getid.h lowpower.c lowpower.h show.c show.h
  group function
    function/: delay.c delay.h gpio.c gpio.h key.c key.h nrf.c nrf.h Voltage.c Voltage.h
  group LIB
    lib/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group README
    ReadME/: ReadMe.txt
  group SYS
    sys/: lcd.c lcd.h spi.c spi.h time.c time.h
  group USER
    user/: main.c stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h sysconfig.c sysconfig.h
